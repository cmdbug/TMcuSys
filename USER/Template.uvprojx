# Keil uVision project Template.uvprojx, settings and files
target WZTENG (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TMcuSys +hex
  c flags: Optim=4 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\CORE;..\FWLIB\STM32F10x_FWLib\inc;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\SRAM;..\HARDWARE\TIMER;..\HARDWARE\SDIO;..\HARDWARE\BEEP;..\HARDWARE\W25QXX;..\MALLOC;..\USMART;..\TEXT;..\FATFS\src;..\FATFS\exfuns;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\EMWIN\STemWin\Config;..\EMWIN\STemWinPNG;..\EMWIN\STemWin\inc;..\EMWIN\STemWinHZ;..\EMWIN\EMWIN_PICTURE\BMP;..\EMWIN\EMWIN_PICTURE\JPEG;..\EMWIN\EMWIN_PICTURE\GIF;..\EMWIN\EMWIN_PICTURE\PNG;..\HARDWARE\SDSPI;..\HARDWARE\RTC;..\EMWIN_DEMO;..\APP;..\T9INPUT;..\HARDWARE\OLED;..\HARDWARE\TPAD;..\HARDWARE\ADXL345;..\HARDWARE\RDA5820;..\HARDWARE\VS10XX;..\HARDWARE\JOYPAD;..\HARDWARE\PS2;..\NES;..\NES\mapper;..\SMS;..\HARDWARE\AUDIOSEL;..\HARDWARE\EXTI;..\HARDWARE\DHT11;..\HARDWARE\DS18B20;..\HARDWARE\NRF24L01;..\HARDWARE\REMOTE;..\HARDWARE\CAN;..\HARDWARE\RS485;..\HARDWARE\OV7670;..\MJPEG;..\MJPEG\JPEG
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SDSPI/: MMC_SD.C
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/TPAD/: tpad.c
    ../HARDWARE/ADXL345/: adxl345.c
    ../HARDWARE/RDA5820/: rda5820.c
    ../HARDWARE/VS10XX/: VS10XX.c
    ../HARDWARE/JOYPAD/: joypad.c
    ../HARDWARE/PS2/: mouse.c ps2.c
    ../HARDWARE/AUDIOSEL/: audiosel.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/OV7670/: ov7670.c sccb.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_crc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_wwdg.c
  group FATFS
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c textfont.c
  group APP
    ../APP/: app.c appicon.c Calculatorapp.c BrowserDLG.c Filescan.c PictureDLG.c PerfMonDLG.c SettingDLG.c SetDateTimeDLG.c appskin.c MessageBoxUser.c ExAppRun.c ExAppRunDLG.c common.c nesplay.c NesPlayDLG.c DateTimeDLG.c MusicDLG.c mp3player.c VideoDLG.c videoplayer.c GUIDEMO_Speed.c GenerateJulia.c
  group PYINPUT
    ../T9INPUT/: keypad.c pyinput.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu.h os_cpu_a.s
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h includes.h
  group EMWIN_Config
    ../EMWIN/STemWin/Config/: GUIConf.c GUIDRV_Template.c GUI_X_Touch_Analog.c LCDConf_FlexColor_Template.c
    ../EMWIN/STemWin/OS/: GUI_X_UCOSIII.c
  group EMWIN_LIB
    ../EMWIN/STemWin/Lib/: STemWin528_CM3_OS_Keil.lib
  group EMWIN_HZ
    ../EMWIN/STemWinHZ/: GUICharPEx.c GUI_FontHZ12.c GUI_FontHZ16.c GUI_FontHZ24.c GUI_UC_EncodeNone.c EmWin_ASCII_Font.h
  group EMWIN_PNG
    ../EMWIN/STemWinPNG/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c gzio.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pnggccrd.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngvcrd.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c
  group EMWIN_PICTURE
    ../EMWIN/EMWIN_PICTURE/BMP/: bmpdisplay.c
    ../EMWIN/EMWIN_PICTURE/GIF/: gifdisplay.c
    ../EMWIN/EMWIN_PICTURE/JPEG/: jpegdisplay.c
    ../EMWIN/EMWIN_PICTURE/PNG/: pngdisplay.c
  group NES
    ../NES/: 6502.s cart.s nes_apu.c nes_main.c nes_mapper.c nes_ppu.c
  group SMS
    ../SMS/: sms_main.c sms_render.c sms_sn76496.c sms_vdp.c sms_z80a.c
  group MJPEG
    ../MJPEG/: avi.c mjpeg.c
    ../MJPEG/JPEG/: jaricom.c jcomapi.c jutils.c jerror.c jmemmgr.c jdapimin.c jdapistd.c jdarith.c jdmaster.c jdinput.c jdmarker.c jdhuff.c jdmainct.c jdcoefct.c jdpostct.c jddctmgr.c jidctfst.c jidctflt.c jfdctint.c jdsample.c jdcolor.c jquant1.c jquant2.c jdmerge.c jmemnobs.c wrppm.c
